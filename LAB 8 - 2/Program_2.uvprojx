# Keil uVision project Program_2.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Program_2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L031K6Tx/STCubeGenerated/Src/: main.c stm32l0xx_it.c
    ./RTE/Device/STM32L031K6Tx/STCubeGenerated/Inc/: stm32l0xx_it.h
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL 1.12.0
